# Keil uVision project qitas.uvproj, settings and files
target qitas (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: n76e003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\usr;.\N76
  group user
    ./usr/: I2C.c mian.c buzzer.c common.c WS281X.c
